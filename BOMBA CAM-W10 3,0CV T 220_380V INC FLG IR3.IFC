Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: W:\PRODUTOS\SERIE CAM\CAM-W10\IFC\BOMBA CAM-W10 3,0CV T 220_380V INC FLG IR3.IFC
Time: 2026-06-08T13:26:47+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
